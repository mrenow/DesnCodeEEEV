# Keil uVision project I2C_ARM.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2478 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2C_ARM
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Source Group 1
    ./: LPC2400.s startup.c communication.s initialize.c bat_ram.s
